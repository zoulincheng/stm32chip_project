# Keil uVision project os_contiki.uvprojx, settings and files
target oscontiki (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: os_contiki +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER
  c include: ..\..\lib\Inc;..\inc;..\..\cmsis\inc;..\..\cmsis\coreinc;..\..\contiki\plantform\stm32f030;..\..\contiki\core;..\..\contiki\cpu\arm\stm32f030
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Objects\os_contiki.sct
  group user
    ../src/: main.c stm32f0xx_it.c
  group cmsis
    ../../cmsis/src/: system_stm32f0xx.c
  group startup
    ../../startup/: startup_stm32f030x8.s
  group stmlib
    ../../lib/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group os_core_sys
    ../../contiki/core/sys/: arg.c autostart.c ctimer.c etimer.c process.c procinit.c stimer.c timer.c
  group os_core_lib
    ../../contiki/core/lib/: crc16.c list.c memb.c mmem.c random.c ringbuf.c
  group os_cpu_arm_stm32f030
    ../../contiki/cpu/arm/stm32f030/: clock.c
