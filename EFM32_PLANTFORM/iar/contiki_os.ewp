# IAR project contiki_os.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG230F128 SiliconLaboratories EFM32LG230F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32LG230F128
  ICCARM.CCIncludePath2: ..\em32\cmsis\include; ..\em32\Device\SiliconLabs\EFM32LG\Include; ..\em32\emlib\inc; ..\xprintf; ..\utility; ..\HWLH-20151211B1; ..\user\driver; ..\user\EFM32LG230F128
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\em32\cmsis\include; ..\em32\Device\SiliconLabs\EFM32LG\Include; ..\em32\emlib\inc
  OBJCOPY.OOCOutputFile: contiki_os.bin
  ILINK.IlinkOutputFile: contiki_os.out
  ILINK.IlinkIcfFile: contiki_os.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EFM32LG/CMSIS
    ../em32/Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../em32/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group EFM32LG/EMLIB
    ../em32/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_crc.c em_cryotimer.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group EFM32LG/user/driver
    ../user/driver/: em32_uart.c em32_uart.h sysprintf.c sysprintf.h
  group EFM32LG/user/platform
    ../user/EFM32LG230F128/: main.c
  group EFM32LG/utility
    ../utility/: common.c utility.c
  group EFM32LG/xprintf
    ../xprintf/: xprintf.c
